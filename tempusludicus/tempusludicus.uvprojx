# Keil uVision project tempusludicus.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: tempusludicus
  c flags: Optim=4 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=2
  c define: CLOCK_SETUP=1
  c misc: -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion -Wno-declaration-after-statement
  c include: .\Core\Inc;.\drivers\LED_StripDriver\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./Core/Src/: main.c rgb.c delay.c sysTick.c timer_dma_ws2812.c lcd_4bit.c unixFunction.c ultrasonic_sensor.c switches.c queue.c uart0.c it_handlers.c pit.c
  group inc
    ./Core/Inc/: delay.h rgb.h main.h sysTick.h timer_dma_ws2812.h common.h it_handlers.h lcd_4bit.h queue.h switches.h uart0.h ultrasonic_sensor.h unixFunction.h pit.h
  group rgbstrip_driver
    ./drivers/LED_StripDriver/: ledcontrol.c ledcontrol.h ws2812_config.h sk6812_config.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0
